Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VMPM2u.IFC
Time: 2024-01-12T08:25:23
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: VMPM2u-01
In: Default Storey
Material: Wood-Concrete

# IfcBuildingElementProxy: VMPMu-11
In: Default Storey
Material: Plywood WBP (Okoume)

# IfcBuildingElementProxy: VMPMu-21
In: Default Storey
Material: Plywood WBP (Okoume)
